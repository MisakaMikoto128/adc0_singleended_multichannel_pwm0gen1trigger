# Keil uVision project adc0_singleended_multichannel_pwm0gen1trigger.uvprojx, settings and files
target adc0_singleended_multichannel_pwm0gen1trigger (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: adc0_singleended_multichannel_pwm0gen1trigger
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: D:\ti\simplelink_msp432e4_sdk_4_20_00_12\source;D:\ti\simplelink_msp432e4_sdk_4_20_00_12\source/third_party/CMSIS/Include/
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source
    ../: adc0_singleended_multichannel_pwm0gen1trigger.c system_msp432e401y.c uartstdio.c
    ./: startup_msp432e401y_uvision.s
  group Library
    ./: msp432e4_driverlib.a
software components: CMSIS:CORE 5.5.0
